# Autodesk Inventor assembly: 21.1783 CORNER 90
## iProperties
Created: 2007-04
Part Number: 21.1783 CORNER 90
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
